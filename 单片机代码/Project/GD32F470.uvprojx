# Keil uVision project GD32F470.uvprojx, settings and files
target GD32F450 (5060960::V5.06 update 7 (build 960)::.\Version5.6)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led;..\Hardware\usart;..\Hardware\key;..\Hardware\timer;..\Hardware\pwm;..\Hardware\OLED;..\User\delay;..\Hardware\sht30;..\Hardware\mlx90614;..\Hardware\esp01s;..\Hardware\ILI9225;..\Hardware\ultrasonic;..\Hardware\usart3;..\Hardware\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: systick.c main.c gd32f4xx_it.c sys.c
    ../User/delay/: delay.c delay.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_usart.c
    ../Hardware/timer/: bsp_basic_timer.c
    ../Hardware/pwm/: bsp_pwm.c
    ../Hardware/sht30/: bsp_sht30.c
    ../Hardware/esp01s/: esp01s.c
    ../Hardware/mlx90614/: bsp_mlx90614.c
    ../Hardware/ILI9225/: GUI.c Font.h Lcd_Driver.c
    ../Hardware/usart3/: bsp_usart3.c bsp_usart3.h
    ../Hardware/key/: bsp_key.c bsp_key.h
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_timer.c gd32f4xx_spi.c
  group Doc
    ../Doc/: readme.txt
